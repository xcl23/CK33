# Keil uVision project peripheral.uvprojx, settings and files
target CK33 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat CK33
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat CK33
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DW16=1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\sample\ble_peripheral;..\ble_peripheral;..\..\..\Applications\System_timer;..\..\..\Applications\Main\inc;..\..\..\Applications\Data_manager;..\..\..\Applications\Arithmetic;..\..\..\Applications\GUI_manager\Common\font;..\..\..\Applications\GUI_manager\Common\language;..\..\..\Applications\GUI_manager\Common\picture\CK33;..\..\..\Applications\GUI_manager\Common\UI_draw\;..\..\..\Applications\GUI_manager\Common\UI_draw\GUI_LIB;..\..\..\Applications\GUI_manager\Common\Window_manager;..\..\..\Applications\GUI_manager\Window_module;..\..\..\Drivers\RTC;..\..\..\Drivers\Motor;..\..\..\Applications\Main\inc;..\..\..\Drivers\LCD;..\..\..\Drivers\PWM;..\..\..\Drivers\Key;..\..\..\Drivers\I2C;..\..\..\Drivers\TP;..\..\..\Drivers\Gsensor;..\..\..\Applications\GUI_manager\Window_module\BP;..\..\..\Applications\GUI_manager\Window_module\heart;..\..\..\Applications\GUI_manager\Window_module\message;..\..\..\Applications\GUI_manager\Window_module\more;..\..\..\Applications\GUI_manager\Window_module\more\breath;..\..\..\Applications\GUI_manager\Window_module\more\photograph;..\..\..\Applications\GUI_manager\Window_module\more\sport;..\..\..\Applications\GUI_manager\Window_module\music;..\..\..\Applications\GUI_manager\Window_module\O2;..\..\..\Applications\GUI_manager\Window_module\other;..\..\..\Applications\GUI_manager\Window_module\quick;..\..\..\Applications\GUI_manager\Window_module\sleep;..\..\..\Applications\GUI_manager\Window_module\steps;..\..\..\Applications\GUI_manager\Window_module\weather;..\..\..\Applications\GUI_manager\Window_module\woman;..\..\..\Drivers\HR_sensor;..\..\..\Drivers\Battery_manager;..\..\..\Drivers\Watchdog;..\..\..\Drivers\Uart;..\..\..\Drivers\HRS3300;..\..\..\Applications\GUI_manager\Common;..\..\..\Applications\GUI_manager
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib bee2_adc_lib.lib
    ../../../Drivers/HRS3300/: m4_keil_20181119_v22_8d_jhglbp.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_rcc.c rtl876x_lcd.c rtl876x_gdma.c rtl876x_i2c.c rtl876x_adc.c rtl876x_uart.c
    ../../../src/flash/: flash_hs_read.c
  group drivers
    ../../../Drivers/RTC/: rtc.c
    ../../../Drivers/Motor/: motor.c
    ../../../Drivers/LCD/: lcd.c
    ../../../Drivers/PWM/: PWM.c
    ../../../Drivers/Key/: key1.c gpio_interrupt.c
    ../../../Drivers/I2C/: I2C0.c
    ../../../Drivers/Gsensor/: sc7a20_driver.c
    ../../../Drivers/Battery_manager/: ADC.c battery_manager.c low_power_mode.c shutdown_mode.c
    ../../../Drivers/HR_sensor/: hr.c
    ../../../Drivers/Watchdog/: wdt.c
    ../../../Drivers/Uart/: io_uart.c
    ../../../Drivers/HRS3300/: hrs3300.c
    ../../../Drivers/TP/CST716/: tp_CST716.c
    ../../../Drivers/TP/Betterlife/: tp_Betterlife.c
    ../../../Drivers/TP/CST816/: tp_CST816.c
  group profile
    ../../../src/ble/profile/server/: simple_ble_service.c hids_kb.c
    ../../../src/ble/profile/client/: ancs_client.c ams.c ams_client.c
  group app
    ../../../src/sample/ble_peripheral/: ancs.c app_task.c peripheral_app.c ble_common.c ancs_parse_data.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
  group application
    ../../../Applications/System_timer/: sys_timer_thread.c data_manager_timer_thread.c mix_timer_thread.c
    ../../../Applications/Main/src/: sys_init.c main.c factory_test.c
    ../../../Applications/Data_manager/: data_common.c data_manager.c data_manager_flash.c data_manager_message.c data_manager_sensor.c data_manager_user_info.c data_manager_watchface.c data_passthrough.c data_receive_package.c data_transfer.c data_transfer_package.c dev_version.c OTA.c ota_updata.c
    ../../../Applications/Arithmetic/: arithmetic_common.c arithmetic_mix_sport.c arithmetic_run.c arithmetic_sleep.c arithmetic_steps.c
    ../../../Applications/GUI_manager/Common/font/: GB2312_font_16x16.c lcd_area.c Roboto14.c
    ../../../Applications/GUI_manager/Common/language/: language.c
    ../../../Applications/GUI_manager/Common/picture/CK33/: picture.c picture_data.c
    ../../../Applications/GUI_manager/Common/Window_manager/: watchface.c window_common.c window_manager.c window_timer_thread.c window_touch.c
    ../../../Applications/GUI_manager/Window_module/: logo_window.c main_window.c
    ../../../Applications/GUI_manager/Window_module/BP/: BP_child_window.c BP_window.c
    ../../../Applications/GUI_manager/Window_module/heart/: heart_child_window.c heart_window.c
    ../../../Applications/GUI_manager/Window_module/message/: message_info_child_window.c message_info_window.c
    ../../../Applications/GUI_manager/Window_module/more/: about_window.c brightness_window.c factory_reset_window.c find_phone_window.c goodbye_window.c lcd_timeout_window.c more_info_window.c QR_code_window.c shutdown_window.c stopwatch_window.c watchface_select_window.c language_window.c
    ../../../Applications/GUI_manager/Window_module/more/sport/: app_sport_window.c sport_info_data_window.c sport_info_window.c
    ../../../Applications/GUI_manager/Window_module/more/photograph/: photograph_child_window.c
    ../../../Applications/GUI_manager/Window_module/more/breath/: breath_child_window.c breath_setting_window.c
    ../../../Applications/GUI_manager/Window_module/music/: music_window.c
    ../../../Applications/GUI_manager/Window_module/O2/: O2_child_window.c O2_window.c
    ../../../Applications/GUI_manager/Window_module/other/: alarm_window.c app_pair_window.c battery_charging_window.c call_window.c drink_alarm_window.c find_device_window.c led_onoff_window.c low_power_window.c message_window.c power_analysis_window.c sedentary_remind_window.c target_window.c test_window.c OTA_window.c NULL_window.c app_language_window.c
    ../../../Applications/GUI_manager/Window_module/quick/: quick_window.c zoom_window.c
    ../../../Applications/GUI_manager/Window_module/sleep/: sleep_window.c
    ../../../Applications/GUI_manager/Window_module/steps/: steps_window.c
    ../../../Applications/GUI_manager/Window_module/weather/: weather_window.c
    ../../../Applications/GUI_manager/Window_module/woman/: woman_child_window.c woman_window.c woman_alarm_window.c
    ../../../Applications/GUI_manager/Window_module/circle_menu/: circle_menu_window.c
  group app/font
    ../../../Applications/GUI_manager/Common/font/: NewSong29.c Roboto35.c Roboto53.c Roboto29.c Roboto24.c FontMenu.c FontMenuArabic0.c
  group ui/draw
    ../../../Applications/GUI_manager/Common/UI_draw/src/: GUI_Font_Digit.c GUI_Picture_Digit.c ui_plug.c
    ../../../Applications/GUI_manager/Common/UI_draw/ui_lib/: ui_lib.c
    ../../../Applications/Main/src/: WRxLib.lib
